options:
  parameters:
    generate_options: qt_gui
    id: PulseDetectGUI
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: final_samp_rate
  id: variable
  parameters:
    value: samp_rate/total_decimation
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '21'
    value: '21'
  states: {}
- name: pulse_freq
  id: variable
  parameters:
    value: '146000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: total_decimation
  id: variable
  parameters:
    value: 16*16*8
  states: {}
- name: PulseDetectBase
  id: PulseDetectBase
  parameters:
    final_decimation: '8'
    gain: gain
    pllFreqMax: '100'
    pulse_duration: '0.015'
    pulse_freq: pulse_freq
    samp_rate: samp_rate
    wnT: math.pi/4.0*0+0.635
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: final_samp_rate
    fc: pulse_freq
    fftsize: '8192'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Spectrum
    name: '"Spectrum"'
    showports: 'True'
    tr_level: '-65.0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 0,1,3,1
    label1: Raw
    min: '0'
    name: '"Pulse Indicator"'
    type: float
    update_time: '0.005'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: Pulse
    name: '"Pulse Processing Views"'
    size: int(final_samp_rate*10.0)
    srate: final_samp_rate
    tr_level: '0'
    type: float
  states: {}

connections:
- [PulseDetectBase, '0', qtgui_number_sink_0, '0']
- [PulseDetectBase, '0', qtgui_time_sink_x_0, '0']
- [PulseDetectBase, '1', blocks_vector_sink_x_0, '0']
- [PulseDetectBase, '1', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
