options:
  parameters:
    generate_options: hb
    id: AudioSource
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=Audio,DEV=0
    samp_rate: '48000'
  states: {}
- name: avg_pulse
  id: pad_sink
  parameters:
    label: Complex Output
    type: complex
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '4000'
    taps: ''
    type: ccc
  states: {}

connections:
- [audio_source_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_magphase_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_null_source_0, '0', blocks_magphase_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', avg_pulse, '0']

metadata:
  file_format: 1
