options:
  parameters:
    generate_options: hb
    id: PulseDetectBase
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: AirspyFileSource_0
  id: AirspyFileSource
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: AirspySource_0
  id: AirspySource
  parameters:
    gain: gain
    pulse_freq: pulse_freq
    samp_rate: samp_rate
  states: {}
- name: AudioSource_0
  id: AudioSource
  parameters: {}
  states: {state: disabled}
- name: PhaseLockLoop_0
  id: PhaseLockLoop
  parameters:
    pllFreqMax: '100'
    pulse_duration: pulse_duration
    samp_rate: final_samp_rate
    wnT: math.pi/4.0*0+0.635
  states: {}
- name: avg_pulse
  id: pad_sink
  parameters:
    label: Average Pulse Output
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: final_samp_rate
  id: parameter
  parameters:
    label: Final Sample Rate
    type: eng_float
    value: 3e6/(16*16*4)
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: intx
    value: '21'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: pulse_duration
  id: parameter
  parameters:
    label: Pulse duration (secs)
    type: eng_float
    value: '0.015'
  states: {}
- name: pulse_freq
  id: parameter
  parameters:
    label: Pulse Freq
    type: intx
    value: '146000000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 3e6
  states: {}
- name: source_index
  id: parameter
  parameters:
    label: Source Index
    type: intx
    value: '0'
  states: {}
- name: spectrum
  id: pad_sink
  parameters:
    label: Decimated Spectrum
    optional: 'True'
    type: complex
  states: {}

connections:
- [AirspyFileSource_0, '0', PhaseLockLoop_0, '0']
- [AirspySource_0, '0', blocks_selector_0, '0']
- [PhaseLockLoop_0, '0', avg_pulse, '0']
- [blocks_selector_0, '0', PhaseLockLoop_0, '0']
- [blocks_selector_0, '0', spectrum, '0']

metadata:
  file_format: 1
