options:
  parameters:
    generate_options: hb
    id: PhaseLockLoop
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: fmax
  id: variable
  parameters:
    value: pllFreqMax
  states: {}
- name: fmin
  id: variable
  parameters:
    value: '-pllFreqMax'
  states: {}
- name: inter_pulse_duration
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: math.pi/(samp_rate/2.0)*fmax
    min_freq: math.pi/(samp_rate/2.0)*fmin
    w: wnT
  states: {}
- name: avg_pulse
  id: pad_sink
  parameters:
    label: Average Pulse Output
    type: float
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate*pulse_duration)
    max_iter: int(samp_rate*inter_pulse_duration/10.0)
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pllFreqMax
  id: parameter
  parameters:
    label: PLL Freq Max
    type: eng_float
    value: '100'
  states: {}
- name: pulse_duration
  id: parameter
  parameters:
    label: Pulse duration (secs)
    type: eng_float
    value: '0.015'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '2929'
  states: {}
- name: wnT
  id: parameter
  parameters:
    label: PLL Loop BW
    type: eng_float
    value: math.pi/4.0*0+0.635
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_complex_to_mag_0_0, '0', avg_pulse, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0_0, '0']
- [pad_source_0, '0', analog_pll_refout_cc_0, '0']
- [pad_source_0, '0', blocks_multiply_conjugate_cc_0, '0']

metadata:
  file_format: 1
