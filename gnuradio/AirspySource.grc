options:
  parameters:
    generate_options: hb
    id: AirspySource
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: DecimateSDR_0
  id: DecimateSDR
  parameters:
    samp_rate: 3e6
  states: {}
- name: avg_pulse
  id: pad_sink
  parameters:
    label: Decimated Output
    type: complex
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: intx
    value: '21'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspy=0,sensitivity
    bb_gain0: '20'
    clock_source0: gpsdo
    freq0: pulse_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pulse_freq
  id: parameter
  parameters:
    label: Pulse Freq
    type: intx
    value: '146000000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 3e6
  states: {}

connections:
- [DecimateSDR_0, '0', avg_pulse, '0']
- [osmosdr_source_0, '0', DecimateSDR_0, '0']

metadata:
  file_format: 1
