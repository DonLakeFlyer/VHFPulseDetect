options:
  parameters:
    generate_options: hb
    id: AirspyFileSource
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: DecimateSDR_0
  id: DecimateSDR
  parameters:
    samp_rate: 3e6
  states: {}
- name: avg_pulse
  id: pad_sink
  parameters:
    label: Decimated Output
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/parallels/vhf.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 3e6
  states: {}

connections:
- [DecimateSDR_0, '0', avg_pulse, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', DecimateSDR_0, '0']

metadata:
  file_format: 1
