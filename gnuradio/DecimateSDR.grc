options:
  parameters:
    generate_options: hb
    id: DecimateSDR
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: decimate_1
  id: variable
  parameters:
    value: '16'
  states: {}
- name: decimate_2
  id: variable
  parameters:
    value: '16'
  states: {}
- name: decimate_3
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: samp_rate/decimate_1
  states: {}
- name: samp_rate3
  id: variable
  parameters:
    value: samp_rate2/decimate_2
  states: {}
- name: samp_rate4
  id: variable
  parameters:
    value: samp_rate3/decimate_3
  states: {}
- name: taps1
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0, samp_rate, 1.5e3, 128e3-1.5e3, 60.0, firdes.WIN_BLACKMAN_HARRIS, 6.76)
  states: {}
- name: taps1_len
  id: variable
  parameters:
    value: len(taps1)
  states: {}
- name: taps2
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0, samp_rate2, 1.5e3, 16e3-1.5e3, 60.0, firdes.WIN_BLACKMAN_HARRIS, 6.76)
  states: {}
- name: taps2_len
  id: variable
  parameters:
    value: len(taps2)
  states: {}
- name: taps3
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0, samp_rate3, 1.5e3, 0.3e3, 30.0, firdes.WIN_KAISER, 6.76/2)
  states: {}
- name: taps3_len
  id: variable
  parameters:
    value: len(taps3)
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimate_2
    taps: taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimate_3
    taps: taps3
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimate_1
    samp_rate: samp_rate
    taps: taps1
    type: ccc
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: decimated_spectrum
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 3e6
  states: {}

connections:
- [fir_filter_xxx_0_0, '0', fir_filter_xxx_0_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', pad_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0_0, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
