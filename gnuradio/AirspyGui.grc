options:
  parameters:
    generate_options: qt_gui
    id: AirspyGui
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: final_samp_rate
  id: variable
  parameters:
    value: samp_rate/total_decimation
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '21'
    value: '21'
  states: {}
- name: pulse_duration
  id: variable
  parameters:
    value: '0.015'
  states: {}
- name: pulse_freq
  id: variable
  parameters:
    value: '146000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: total_decimation
  id: variable
  parameters:
    value: 16*16*4
  states: {}
- name: AirspyFileSource_0
  id: AirspyFileSource
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: AirspySource_0
  id: AirspySource
  parameters:
    gain: gain
    pulse_freq: pulse_freq
    samp_rate: samp_rate
  states: {}
- name: PhaseLockLoop_0
  id: PhaseLockLoop
  parameters:
    pllFreqMax: '100'
    pulse_duration: pulse_duration
    samp_rate: samp_rate/(16*16*4)
    wnT: math.pi/4.0*0+0.635
  states: {}
- name: VHFPulseDetect_pulse_detect_ff_0
  id: VHFPulseDetect_pulse_detect_ff
  parameters:
    pulseDuration: pulse_duration
    sampleRate: int(final_samp_rate)
    threshold: '3'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: final_samp_rate
    fc: pulse_freq
    fftsize: '8192'
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: Spectrum
    name: '"Spectrum"'
    showports: 'True'
    tr_level: '-65.0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 0,1,5,1
    label1: Raw
    min: '0'
    name: '"Pulse Indicator"'
    type: float
    update_time: '0.005'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4,0,1,1
    label1: Pulse
    name: '"Pulse Processing Views"'
    size: int(final_samp_rate*10.0)
    srate: final_samp_rate
    tr_level: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 5,0,1,1
    label1: pulseDetect
    label2: pulse
    label3: movingAverage
    label4: movingVariance
    label5: movingStdDev
    label6: threshold
    name: '"Pulse Processing Views"'
    nconnections: '6'
    size: int(final_samp_rate*10.0)
    srate: final_samp_rate
    style2: '3'
    style3: '2'
    style4: '2'
    style6: '0'
    tr_level: '0'
    type: float
  states: {}

connections:
- [AirspyFileSource_0, '0', PhaseLockLoop_0, '0']
- [AirspySource_0, '0', PhaseLockLoop_0, '0']
- [AirspySource_0, '0', qtgui_freq_sink_x_0, '0']
- [PhaseLockLoop_0, '0', VHFPulseDetect_pulse_detect_ff_0, '0']
- [PhaseLockLoop_0, '0', qtgui_number_sink_0, '0']
- [PhaseLockLoop_0, '0', qtgui_time_sink_x_0, '0']
- [VHFPulseDetect_pulse_detect_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [VHFPulseDetect_pulse_detect_ff_0, '1', qtgui_time_sink_x_0_0, '1']
- [VHFPulseDetect_pulse_detect_ff_0, '2', qtgui_time_sink_x_0_0, '2']
- [VHFPulseDetect_pulse_detect_ff_0, '3', qtgui_time_sink_x_0_0, '3']
- [VHFPulseDetect_pulse_detect_ff_0, '4', qtgui_time_sink_x_0_0, '4']
- [VHFPulseDetect_pulse_detect_ff_0, '5', qtgui_time_sink_x_0_0, '5']

metadata:
  file_format: 1
