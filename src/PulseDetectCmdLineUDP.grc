options:
  parameters:
    generate_options: no_gui
    id: PulseDetectCmdLineUDP
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: final_samp_rate
  id: variable
  parameters:
    value: samp_rate/total_decimation
  states: {}
- name: total_decimation
  id: variable
  parameters:
    value: 16*16*final_decimation
  states: {}
- name: PulseDetectBase
  id: PulseDetectBase
  parameters:
    final_decimation: final_decimation
    gain: gain
    pllFreqMax: '100'
    pulse_duration: pulse_duration
    pulse_freq: pulse_freq
    samp_rate: samp_rate
    wnT: math.pi/4.0*0+0.635
  states: {}
- name: VHFPulseDetect_pulse_detect_ff_0
  id: VHFPulseDetect_pulse_detect_ff
  parameters:
    pulseDuration: pulse_duration
    sampleRate: int(final_samp_rate)
    threshold: '2.5'
  states: {}
- name: VHFPulseSender_udp_sender_f_0
  id: VHFPulseSender_udp_sender_f
  parameters:
    channel_index: channel_index
    localhost: localhost
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {}
- name: blocks_vector_sink_x_1
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_1_1
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_1_1_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_1_2
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: blocks_vector_sink_x_1_3
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: channel_index
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: final_decimation
  id: parameter
  parameters:
    type: intx
    value: '4'
  states: {}
- name: gain
  id: parameter
  parameters:
    type: intx
    value: '21'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: localhost
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: pulse_duration
  id: parameter
  parameters:
    type: eng_float
    value: '0.015'
  states: {}
- name: pulse_freq
  id: parameter
  parameters:
    type: intx
    value: '146000000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 3e6
  states: {}

connections:
- [PulseDetectBase, '0', VHFPulseDetect_pulse_detect_ff_0, '0']
- [PulseDetectBase, '1', blocks_vector_sink_x_0, '0']
- [VHFPulseDetect_pulse_detect_ff_0, '0', VHFPulseSender_udp_sender_f_0, '0']
- [VHFPulseDetect_pulse_detect_ff_0, '1', blocks_vector_sink_x_1_1_0, '0']
- [VHFPulseDetect_pulse_detect_ff_0, '2', blocks_vector_sink_x_1_2, '0']
- [VHFPulseDetect_pulse_detect_ff_0, '3', blocks_vector_sink_x_1, '0']
- [VHFPulseDetect_pulse_detect_ff_0, '4', blocks_vector_sink_x_1_1, '0']
- [VHFPulseDetect_pulse_detect_ff_0, '5', blocks_vector_sink_x_1_3, '0']

metadata:
  file_format: 1
