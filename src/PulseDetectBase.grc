options:
  parameters:
    generate_options: hb
    id: PulseDetectBase
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: decimate_1
  id: variable
  parameters:
    value: '16'
  states: {}
- name: decimate_2
  id: variable
  parameters:
    value: '16'
  states: {}
- name: decimate_3
  id: variable
  parameters:
    value: final_decimation
  states: {}
- name: fmax
  id: variable
  parameters:
    value: pllFreqMax
  states: {}
- name: fmin
  id: variable
  parameters:
    value: '-pllFreqMax'
  states: {}
- name: inter_pulse_duration
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: samp_rate/decimate_1
  states: {}
- name: samp_rate3
  id: variable
  parameters:
    value: samp_rate2/decimate_2
  states: {}
- name: samp_rate4
  id: variable
  parameters:
    value: samp_rate3/decimate_3
  states: {}
- name: taps1
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0, samp_rate, 1.5e3, 128e3-1.5e3, 60.0, firdes.WIN_BLACKMAN_HARRIS, 6.76)
  states: {}
- name: taps1_len
  id: variable
  parameters:
    value: len(taps1)
  states: {}
- name: taps2
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0, samp_rate2, 1.5e3, 16e3-1.5e3, 60.0, firdes.WIN_BLACKMAN_HARRIS, 6.76)
  states: {}
- name: taps2_len
  id: variable
  parameters:
    value: len(taps2)
  states: {}
- name: taps3
  id: variable
  parameters:
    value: firdes.low_pass_2(1.0, samp_rate3, 1.5e3, 0.3e3, 30.0, firdes.WIN_KAISER, 6.76/2)
  states: {}
- name: taps3_len
  id: variable
  parameters:
    value: len(taps3)
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: math.pi/(samp_rate4/2.0)*fmax
    min_freq: math.pi/(samp_rate4/2.0)*fmin
    w: wnT
  states: {}
- name: avg_pulse
  id: pad_sink
  parameters:
    label: Average Pulse Output
    type: float
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/parallels/repos/VHFCollarCompanion/far.dat
    repeat: 'False'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate4*pulse_duration)
    max_iter: int(samp_rate4*inter_pulse_duration/10.0)
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: final_decimation
  id: parameter
  parameters:
    label: Final decimation
    type: intx
    value: '4'
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimate_2
    taps: taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimate_3
    taps: taps3
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimate_1
    samp_rate: samp_rate
    taps: taps1
    type: ccc
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: intx
    value: '21'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspy=0,sensitivity
    bb_gain0: '20'
    clock_source0: gpsdo
    freq0: pulse_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pllFreqMax
  id: parameter
  parameters:
    label: PLL Freq Max
    type: eng_float
    value: '100'
  states: {}
- name: pulse_duration
  id: parameter
  parameters:
    label: Pulse duration (secs)
    type: eng_float
    value: '0.015'
  states: {}
- name: pulse_freq
  id: parameter
  parameters:
    label: Pulse Freq
    type: intx
    value: '146000000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 3e6
  states: {}
- name: spectrum
  id: pad_sink
  parameters:
    label: Decimated Spectrum
    optional: 'True'
    type: complex
  states: {}
- name: wnT
  id: parameter
  parameters:
    label: PLL Loop BW
    type: eng_float
    value: math.pi/4.0*0+0.635
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_complex_to_mag_0_0, '0', avg_pulse, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [fir_filter_xxx_0_0, '0', fir_filter_xxx_0_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_0_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fir_filter_xxx_0_0_0, '0', spectrum, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
